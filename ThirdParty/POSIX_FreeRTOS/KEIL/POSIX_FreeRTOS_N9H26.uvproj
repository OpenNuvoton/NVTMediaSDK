# Keil uVision project POSIX_FreeRTOS_N9H26.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: POSIX_FreeRTOS (library)
  AfterMake: xcopy /y .\Output\POSIX_FreeRTOS.lib ..\..\..\PrebuildLib\N9H26\ARMCC\
  c flags: Optim=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\FreeRTOS\Source\include;..\Portable\N9H26\ARMCC;..\POSIX\include;..\POSIX\include\portable;..\include;..\include\private
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group POSIX
    ../POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group Portable
    ../Portable/N9H26/ARMCC/: port.c portASM.s
