# Keil uVision project ImgProc_N9H26.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: ImgProc (library)
  AfterMake: xcopy /y .\Output\ImgProc.lib ..\..\..\PrebuildLib\N9H26\ARMCC\
  c flags: Optim=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\inc;..\..\NuMedia\inc;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group src
    ../src/: ImgProc.c VPE.c
