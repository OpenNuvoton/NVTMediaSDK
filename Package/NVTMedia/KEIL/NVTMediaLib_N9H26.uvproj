# Keil uVision project NVTMediaLib_N9H26.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVTMedia (library)
  AfterMake: xcopy /y .\Output\NVTMedia.lib ..\..\..\PrebuildLib\N9H26\ARMCC\
  c flags: Optim=1 wLevel=2
  c define: __N9H26__
  c misc: --c99
  c include: ..\inc;..\src;..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\..\ImgProc\inc;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\AAC\inc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Media
    ../src/Media/AVI/: AVIReader.c AVIUtility.c AVIWriter.c
    ../src/Media/MP4/: MP4Reader.c
  group Util
    ../src/Util/: Util.c NMPacket.c NMVideoList.c NMAudioList.c
  group Codec
    ../src/Codec/: G711Decoder.c H264Decoder.c AACDecoder.c G711Encoder.c H264Encoder.c H264Ratecontrol.c
  group Play
    ../src/Play/: Player.c PlayEngine.c PlayDecode.c PlayDeMux.c
  group Record
    ../src/Record/: Record.c RecordEngine.c RecordMux.c RecordEncode.c
