# Keil uVision project NMPlayer_CMD.uvproj, settings and files
target NMPlayer_CMD_SD_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NMPlayer_CMD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __N9H26__ STORAGE_SD LCD_QVGA
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\..\..\BSP\N9H26_emWin_NonOS\BSP\ThirdParty\emWin\Include;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include\portable;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\Package\NVTMedia\inc;..\..\..\ThirdParty\tiny-regex-c;..\inc
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Startup
    ../src/StartUp/: main.c wb_init.s standalone.c multithread.c Retarget.c
  group Application
    ../src/Application/: PCMPlayback.c Render.c FileList.c TaskCmdline.c Player.c
  group NVTMedia
    ../../../PrebuildLib/N9H26/ARMCC/: POSIX_FreeRTOS.lib N9H26_AACDecoder.lib ImgProc.lib NVTMedia.lib
    ../../../Package/NVTMedia/src/SAL/: NVTMedia_SAL_FS.c
  group re
    ../../../ThirdParty/tiny-regex-c/: re.c
  group Lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_VPOST_FW050TFT_800x480.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_SIC.lib N9H26_SYS_FreeRTOS.lib N9H26_AAC.lib N9H26_GPIO.lib N9H26_VPE.lib N9H26_H264Codec.lib N9H26_SPU.lib
    ../../../PrebuildLib/N9H26/ARMCC/: N9H26_NVTFAT_FREERTOS_1B.lib
target NMPlayer_CMD_SD_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NMPlayer_CMD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: __N9H26__ STORAGE_SD LCD_WVGA
  c misc: --c99
  c include: as above
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
