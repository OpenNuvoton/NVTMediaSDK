# Keil uVision project NMRecorder_GUI.uvproj, settings and files
target NMRecorder_GUI_SD_QVGA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NMRecorder_GUI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __N9H26__ STORAGE_SD
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\..\..\BSP\N9H26_emWin_NonOS\BSP\ThirdParty\emWin\Include;..\..\..\BSP\N9H26_emWin_NonOS\BSP\SampleCode\VideoIn;..\inc;..\..\..\Package\NVTMedia\inc;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include\portable
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go --verbose
  group StartUp
    ../src/StartUp/: main.c multithread.c Retarget.c standalone.c wb_init.s
  group Libs
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_SYS_FreeRTOS.lib N9H26_VPE.lib N9H26_GPIO.lib N9H26_SIC.lib N9H26_H264Codec.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_I2C.lib N9H26_VideoIn.lib N9H26_AUR.lib N9H26_EDMA.lib N9H26_ADC.lib N9H26_BLT.lib N9H26_AAC.lib
    ../../../PrebuildLib/N9H26/ARMCC/: POSIX_FreeRTOS.lib NVTMedia.lib N9H26_NVTFAT_FREERTOS_1B.lib ImgProc.lib N9H26_AACDecoder.lib N9H26_AACEncoder.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group NVTMedia
    ../../../Package/NVTMedia/src/SAL/: NVTMedia_SAL_FS.c
  group Application
    ../src/Application/: Render.c MainTask.c FileMgr.c TaskGUIDemo.c TaskTouching.c Recorder.c RecordingDLG.c
  group VideoIn
    ../src/VideoIn/: VideoIn.c SensorNT99141.c DrvI2C.c
  group AudioIn
    ../src/AudioIn/: AudioIn.c AurEDMA.c
  group tslib
    ../src/tslib/: fbutils.c N9H26TouchPanel.c testutils.c ts_calibrate.c
  group GUI_Config
    ../src/GUI_Config/: GUI_X.c GUIConf.c LCDConf.c
