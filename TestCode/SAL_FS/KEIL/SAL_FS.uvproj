# Keil uVision project SAL_FS.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: POSIX_FreeRTOS_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __N9H26__,__UNISTD_FILE__
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\inc;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include\portable;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\Package\NVTMedia\inc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go --verbose
  group StartUp
    ../src/StartUp/: main.c multithread.c Retarget.c standalone.c wb_init.s
  group Libs
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_SYS_FreeRTOS.lib N9H26_SIC.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/NVTFATLib/: N9H26_NVTFAT.lib
    ../../../PrebuildLib/N9H26/ARMCC/: POSIX_FreeRTOS.lib
  group SAL
    ../../../Package/NVTMedia/src/SAL/: NVTMedia_SAL_FS.c
  group Src
    ../src/: SAL_FS.c
