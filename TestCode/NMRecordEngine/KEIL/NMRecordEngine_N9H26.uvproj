# Keil uVision project NMRecordEngine_N9H26.uvproj, settings and files
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NMRecordEngine
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __N9H26__
  c misc: --c99
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\inc;..\..\..\Package\NVTMedia\inc;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go --verbose
  group StartUp
    ../src/StartUp/: main.c multithread.c Retarget.c standalone.c wb_init.s
  group Libs
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_SYS_FreeRTOS.lib N9H26_GPIO.lib N9H26_SIC.lib N9H26_H264Codec.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_I2C.lib N9H26_VideoIn.lib
    ../../../PrebuildLib/N9H26/ARMCC/: N9H26_NVTFAT_FREERTOS.lib POSIX_FreeRTOS.lib NVTMedia.lib
  group SAL
    ../../../Package/NVTMedia/src/SAL/: NVTMedia_SAL_FS.c
  group MainTask
    ../src/MainTask/: MainTask.c
  group VideoIn
    ../src/VideoIn/: VideoIn.c SensorNT99141.c DrvI2C.c
