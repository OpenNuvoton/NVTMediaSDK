# Keil uVision project POSIX_FreeRTOS_emWin_GUIDemo_N9H26K5.uvproj, settings and files
target POSIX_FreeRTOS_emWin_GUIDemo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: POSIX_FreeRTOS_emWin_GUIDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Driver\Include;..\..\..\BSP\N9H26_emWin_NonOS\BSP\ThirdParty\emWin\Include;..\..\..\ThirdParty\POSIX_FreeRTOS\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include;..\..\..\ThirdParty\POSIX_FreeRTOS\Portable\N9H26\ARMCC;..\..\..\ThirdParty\POSIX_FreeRTOS\FreeRTOS\Source\include;..\..\..\ThirdParty\POSIX_FreeRTOS\POSIX\include\portable;..\..\..\ThirdParty\POSIX_FreeRTOS\include\private;..\..\..\BSP\N9H26_emWin_NonOS\BSP\SampleCode\emWin\GUIDemo\Application;..\..\..\BSP\N9H26_emWin_NonOS\BSP\SampleCode\emWin\GUIDemo\tslib;..\emwin_config;..\StartUp
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\BSP\N9H26_emWin_NonOS\BSP\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Startup
    ../StartUp/: main.c wb_init.s standalone.c multithread.c Retarget.c
  group Lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/IPLib/: N9H26_GIANTPLUS_GPM1006D.lib N9H26_ADC.lib N9H26_SIC.lib N9H26_BLT.lib N9H26_JPEG.lib N9H26_SYS_FreeRTOS.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/GNANDLib/: N9H26_GNAND.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/Library/NVTFATLib/: N9H26_NVTFAT.lib
    ../../../PrebuildLib/N9H26/ARMCC/: POSIX_FreeRTOS.lib
    ../../../BSP/N9H26_emWin_NonOS/BSP/ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group tslib
    ../../../BSP/N9H26_emWin_NonOS/BSP/SampleCode/emWin/GUIDemo/tslib/: ts_calibrate.c fbutils.c testutils.c N9H26TouchPanel.c
  group GUI_Config
    ../emwin_config/: LCDConf.c GUI_X.c LCDConf.h GUIConf.h
  group Application
    ../../../BSP/N9H26_emWin_NonOS/BSP/SampleCode/emWin/GUIDemo/Application/: GUIConf.c GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
